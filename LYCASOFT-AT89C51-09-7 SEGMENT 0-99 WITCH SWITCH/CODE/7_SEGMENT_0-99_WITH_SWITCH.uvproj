# Keil uVision project 7_SEGMENT_0-99_WITH_SWITCH.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 7_SEGMENT_0-99_WITH_SWITCH +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 7_SEGMENT_0-99_WITH_SWITCH.c
